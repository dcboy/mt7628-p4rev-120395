## src/embedded/mt_wifi_sta/Kconfig
```kconfig
config MT_STA_SUPPORT
	tristate "Mediatek 802.11n STA support"
#	depends on NET_RADIO 
	select WIRELESS_EXT
	select WEXT_SPY
	select WEXT_PRIV
```
